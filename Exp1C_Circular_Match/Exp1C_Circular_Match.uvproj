# Keil uVision project Exp1C_Circular_Match.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80C51BH Intel
  cpu: IRAM(0-0x7F)  IROM(0-0xFFF) CLOCK(12000000)
  output: Exp1C_Circular_Match +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Exp1C_Circular_Match.A51
