# Keil uVision project Exp1B_Extra1.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80C51BH Intel
  cpu: IRAM(0-0x7F)  IROM(0-0xFFF) CLOCK(12000000)
  output: Exp1B_Extra1
  c flags: Optimize=8 SizeSpeed=1
