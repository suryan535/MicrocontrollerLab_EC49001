# Keil uVision project 8255_LED_blink.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80C51BH Intel
  cpu: IRAM(0-0x7F)  IROM(0-0xFFF) CLOCK(12000000)
  output: 8255_LED_blink +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 8255_LED_blink.A51
